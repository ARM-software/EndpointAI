# Keil uVision project fakeFileFramework.uvprojx, settings and files
target mps2_cortex_m55 (6140000::V6.14::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: fakeFileFramework
  c flags: OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: _MSC_VER,__USE_COMPILER_SPECIFIED_CMSIS_PATH__, __FILE_INCOMPLETE=1
  c misc: -Omax -fms-extensions -Wno-missing-declarations -Wno-microsoft-anon-tag -Wno-empty-body -Wno-initializer-overrides
  c include: ..\..\
  asm misc: -masm=armasm -mfpu=none -mcpu=cortex-m4
  asm include: ..\..\fake_file_framework\
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Yamin_DTCM.sct
  link misc: --entry=Reset_Handler
  group utilities
    ../../utilities/: compiler.h
    ../../utilities/arm/: arm_compiler.h
    ../../utilities/3rd-party/PLOOC/: plooc_class_strict.h plooc_class_simple.h plooc_class_black_box.h plooc_class.h plooc.h
  group example
    ../../: example_main.c app_cfg.h printf_retarget.c
  group fake_file_framework
    ../../fake_file_framework/: app_cfg.h fake_file_framework.c fake_file_framework.h file_retarget.c file_io.h fff_user_description.c __memory_file.h __memory_file.c hotel.s
    ../../../release/fff_library/: fff_armv6m_lib.lib fff_armv7m_lib.lib
target mps2_armv7m (6140000::V6.14::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fakeFileFramework
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: as above
  c misc: as above
  c include: ..\..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler
target fff_armv7m_lib (6140000::V6.14::ARMCLANG)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fff_armv7m_lib (library)
  AfterMake: cmd.exe /c copy /B  .\Objects\fff_armv7m_lib.lib  .\..\..\..\release\fff_library
  c flags: Optim=6 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: as above
  c misc: -fms-extensions -Wno-missing-declarations -Wno-microsoft-anon-tag -Wno-empty-body -Wno-initializer-overrides
  c include: ..\..\
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler
target mps2_armv7m_template (6140000::V6.14::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: as above
  output: mps2_armv7m_template
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: as above
  c misc: as above
  c include: ..\..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler
target fff_armv6m_lib (6140000::V6.14::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: fff_armv6m_lib (library)
  AfterMake: cmd.exe /c copy /B  .\Objects\fff_armv6m_lib.lib  .\..\..\..\release\fff_library
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: ..\..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2, Device:Startup 1.0.0, Device:Startup 1.0.0, Device:Startup 1.0.0
