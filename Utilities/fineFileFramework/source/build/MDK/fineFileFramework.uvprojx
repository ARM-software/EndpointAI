# Keil uVision project fineFileFramework.uvprojx, settings and files
target mps2_cortex_m55 (6190000::V6.19::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: fineFileFramework
  c flags: OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: _MSC_VER,__USE_COMPILER_SPECIFIED_CMSIS_PATH__, __FILE_INCOMPLETE=1
  c misc: -Omax -fms-extensions -Wno-missing-declarations -Wno-microsoft-anon-tag -Wno-empty-body -Wno-initializer-overrides
  c include: ..\..\
  asm include: ..\..\fine_file_framework\
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\CM55_DTCM.sct
  link misc: --entry=Reset_Handler
  group example
    ../../: example_main.c printf_retarget.c
  group fine_file_framework
    ../../fine_file_framework/: fine_file_framework.c fine_file_framework.h file_retarget.c file_io.h fff_user_description.c __memory_file.h __memory_file.c
    ../../../release/fff_library/: fff_armv6m_lib.lib fff_armv7m_lib.lib
    ../../fine_file_framework/template/: __fff_user_def_file_framework.c fff_cfg.h
target mps2_armv7m (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fineFileFramework
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: __USE_COMPILER_SPECIFIED_CMSIS_PATH__, __FILE_INCOMPLETE=1
  c include: ..\..\;..\..\incbin;..\..\fine_file_framework;..\..\fine_file_framework\template;.\RTE\File_System
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler
target mps2_armv7m_pack_test (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: as above
  output: fineFileFramework
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=5 v6Lto=1 wLevel=3
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler
software components: File System:fine File Framework:Core 1.0.0, CMSIS:CORE 5.6.0, Device:Startup 1.1.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.1.0
