# Keil uVision project template.uvprojx, settings and files
target DO_NOT_USE_V2M-MPS3-CM33 (6160000::V6.16::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0,EXTERANL_DELAY_MS_DECLARE="extern void delay_ms(uint32_t);"
  c misc: -Omax
  c include: ..\..\platform;..\..\platform\mps3\v2m_mps3;..\..\..\..\Library\Include;..\..\platform\mps3;.;..\..\..\..\Helper\Include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\MPS3_M33.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
  group Source Files
    ../../: main.c app_cfg.h example_gui.c example_gui.h
  group platform
    ../../../common/platform/: app_platform.c Board_GLCD.h GLCD_Fonts.c lcd_printf.c lcd_printf.h platform.h
    ../../../common/platform/lib/: perf_counter.h perf_counter.lib
  group asset
    ../../../common/asset/: SpinWheel.c whilte_dot.c.c
  group controls
    ../../../common/controls/: busy_wheel.c busy_wheel.h controls.c controls.h shape_round_corner_box.c shape_round_corner_box.h spinning_wheel.c spinning_wheel.h
  group bsp_mps2
    ../../../common/platform/mps2/: GLCD_V2M-MPS2.c platform_mps2.c stdout_USART.c GLCD_Config.h
  group bsp_mps3
    ../../../common/platform/mps3/: GLCD_V2M-MPS3_AN540.c platform_mps3.c stdout_USART.c GLCD_Config.h
  group bsp_stm32f746g-discovery
    ../../../common/platform/stm32f746g-discovery/: GLCD_746G_Discovery.c platform_stm32f746g_discovery.c GLCD_Config.h
target V2M-MPS2-CM4 (6170000::V6.17::.\ARMCompiler6.17)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IROM(0x00000000,0x400000) IRAM(0x20000000,0x400000) CPUTYPE("Cortex-M4") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=6 oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\lib
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
target FastModel (6180000::V6.18::.\ArmCompilerforEmbedded6.18)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: as above
  output: template
  c flags: Optim=6 oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0,ITERATION_CNT=10
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\lib
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler --diag_suppress=6314,6329
target V2M-MPS2-CM33 (6170000::V6.17::.\ARMCompiler6.17)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.4.2
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: template
  c flags: as above
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\lib;..\..\..\common\platform\mps3\v2m_mps3
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  scatter file: .\MPS2_CM33.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
target V2M-MPS3-CM55 (6170000::V6.17::.\ARMCompiler6.17)
  device: ARMCM55 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: LCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\lib;..\..\..\common\platform\mps3\v2m_mps3;..\..\..\common\platform\mps3
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MPS3_CM55_DTCM.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
target V2M-MPS2-CM0+ (6170000::V6.17::.\ARMCompiler6.17)
  device: CMSDK_CM0plus ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\lib
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
target V2M-MPS2-CM7 (6170000::V6.17::.\ARMCompiler6.17)
  device: CMSDK_CM7_DP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax -Wno-nonportable-include-path
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\lib
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
target STM32F746G-Discovery (6180000::V6.18::.\ArmCompilerforEmbedded6.18)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: template
  c flags: as above
  c define: __ARM_2D_HAS_ANTI_ALIAS_TRANSFORM__=1
  c misc: -Wno-nonportable-include-path
  c include: ..\..\..\common\platform;..\..\..\common\platform\stm32f746g-discovery;..\..\;..\..\..\common\platform\lib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x3f800
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\stm32f746g.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
target AN547-Cortex-M55_r0 (6170000::V6.17::.\ARMCompiler6.17)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: LCD_MIRROR_X=1,GLCD_MIRROR_Y=0,__USE_AN547__
  c misc: -Omax -Wno-padded
  c include: as above
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\MPS3_CM55_DTCM.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
target STM32F746G-Discovery-AC5 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: as above
  output: template
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x3f800
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\stm32f746g.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Device:Definition 1.1.0, Device:Startup 1.3.0, Device:Startup 1.1.0, Device:Startup 1.1.0, Acceleration:Arm-2D Helper:PFB 1.0.0-preview, Acceleration:Arm-2D:Alpha-Blending 1.0.0-preview, Acceleration:Arm-2D:Core 1.0.0-preview, Acceleration:Arm-2D:Transform 1.0.0-preview, Compiler:I/O:STDOUT 1.2.0, Board Support:Drivers:SDRAM 1.1.1, Board Support:Common 2.0.0, Board Support:Common 2.0.0, CMSIS Driver:USART 1.0.3, CMSIS Driver:USART 1.0.0, CMSIS Driver:USART 1.16.0, Device:STM32Cube Framework:Classic 1.2.8, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:LTDC 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:STM32Cube HAL:SDRAM 1.2.8, Device:STM32Cube LL:Common 1.2.8, Device:STM32Cube LL:PWR 1.2.8, Device:STM32Cube LL:RCC 1.2.8, Device:STM32Cube LL:UTILS 1.2.8, Device:Startup 1.0.0, Device:Startup 1.0.0, Device:Startup 1.0.0, Device:Startup 1.0.3, Device:Startup 1.2.5
