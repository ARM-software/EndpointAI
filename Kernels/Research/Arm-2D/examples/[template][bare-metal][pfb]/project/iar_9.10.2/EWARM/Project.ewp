# IAR project Project.ewp, settings and files
configuration STM32746G_DISCOVERY (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F756xx; USE_STM32746G_DISCOVERY
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/BSP/STM32746G-Discovery; ../Drivers/BSP/Components/Common; ../Utilities/Log; ../Utilities/Fonts; ../Utilities/CPU; ..\..\..\..\..\Helper\Include; ..\..\..\..\..\Library\Include; ..\..\..\platform\stm32f746g-discovery; ..\..\..\platform; ..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32746G_DISCOVERY.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: C:\Work\CPMK\Git\cmsis-2d\examples\[template][bare-metal][pfb]\project\iar_9.10.2\EWARM\stm32f746xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\platform\lib\libperf_counter_gcc.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: app_cfg.h example_gui.c example_gui.h main.c
  group Application/Asset
    ../../../asset/: whilte_dot.c.c
  group Application/Controls
    ../../../controls/: busy_wheel.c busy_wheel.h controls.c controls.h
  group Arm-2D/Helper
    ../../../../../Helper/Include/: arm_2d_helper.h arm_2d_helper_pfb.h
    ../../../../../Helper/Source/: arm_2d_helper_pfb.c
  group Arm-2D/Library/Include
    ../../../../../Library/Include/: __arm_2d_paving.h arm_2d.h arm_2d_alpha_blending.h arm_2d_conversion.h arm_2d_draw.h arm_2d_features.h arm_2d_op.h arm_2d_tile.h arm_2d_transform.h arm_2d_types.h arm_2d_utils.h
  group Arm-2D/Library/Source
    ../../../../../Library/Source/: arm_2d.c arm_2d_alpha_blending.c arm_2d_async.c arm_2d_conversion.c arm_2d_draw.c arm_2d_helium.c arm_2d_transform.c
  group Platform
    ../../../platform/: app_platform.c GLCD_Fonts.c lcd_printf.c
  group Platform/Perf_counter
    ../../../platform/lib/: perf_counter.h
  group STM32F746_Discovery/Doc
    ../: readme.txt
  group STM32F746_Discovery/Drivers/BSP/STM32746G-Discovery
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c
  group STM32F746_Discovery/Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group STM32F746_Discovery/Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c
  group STM32F746_Discovery/User
    ../../../platform/stm32f746g-discovery/: GLCD_746G_Discovery.c startup_ARMCM7.c
    ../Src/: stm32f746_discovery_platform.c stm32f7xx_hal_msp.c stm32f7xx_it.c
