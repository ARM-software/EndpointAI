# Keil uVision project gcc_template.uvprojx, settings and files
target STM32F746G-Discovery-GCC (6160000::V6.16::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: gcc_template
  AfterMake: arm-none-eabi-size.exe ./Objects/gcc_template.elf
  group Application
    ./: example_gui.c example_gui.h app_cfg.h main.c
  group Platform
    ./RTE/Device/STM32F746NGHx/: system_stm32f7xx.c
    ../common/platform/: app_platform.c GLCD_Fonts.c lcd_printf.c platform.h
    ../common/platform/stm32f746g-discovery/: GLCD_746G_Discovery.c platform_stm32f746g_discovery.c startup_ARMCM7.c
    ../common/platform/lib/: perf_counter.c perf_counter.h perf_os_patch_rtx5.c
  group Controls
    ../common/controls/: busy_wheel.c busy_wheel.h controls.c controls.h shape_round_corner_box.c shape_round_corner_box.h spinning_wheel.c spinning_wheel.h
  group asset
    ../common/asset/: whilte_dot.c.c SpinWheel.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, CMSIS:RTOS2:Keil RTX5 5.5.3, Acceleration:Arm-2D Helper:PFB 1.0.0-preview, Acceleration:Arm-2D:Alpha-Blending 1.0.0-preview, Acceleration:Arm-2D:Core 1.0.0-preview, Acceleration:Arm-2D:Transform 1.0.0-preview, Board Support:Drivers:SDRAM 1.1.1, CMSIS Driver:USART 1.16.0, Device:STM32Cube Framework:Classic 1.2.8, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:LTDC 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:STM32Cube HAL:SDRAM 1.2.8, Device:STM32Cube HAL:USART 1.2.8, Device:STM32Cube LL:Common 1.2.8, Device:STM32Cube LL:PWR 1.2.8, Device:STM32Cube LL:RCC 1.2.8, Device:STM32Cube LL:USART 1.2.8, Device:STM32Cube LL:UTILS 1.2.8, Device:Startup 1.2.5
