# Keil uVision project gcc_benchmark.uvprojx, settings and files
target STM32F746G-Discovery-GCC (6160000::V6.16::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: gcc_benchmark
  AfterMake: arm-none-eabi-size.exe ./Objects/gcc_partial_frame_buffer.elf
  group Application
    ./: example_gui.c example_gui.h app_cfg.h main.c
  group Platform
    ./platform/: GLCD_Fonts.c app_platform.c lcd_printf.c lcd_printf.h platform.h
    ./platform/stm32f746g-discovery/: GLCD_746G_Discovery.c platform_stm32f746g_discovery.c startup_ARMCM7.c
    ./RTE/Device/STM32F746NGHx/: system_stm32f7xx.c
    ./platform/lib/: libperf_counter_gcc.a perf_counter.h
  group Arm-2D
    ../../Library/Include/: __arm_2d_impl.h __arm_2d_paving.h __arm_2d_paving_helium.h arm_2d.h arm_2d_alpha_blending.h arm_2d_conversion.h arm_2d_draw.h arm_2d_features.h arm_2d_tile.h arm_2d_types.h arm_2d_utils.h arm_2d_rotation.h
    ../../Library/Source/: __arm_2d_alpha_blending.inc __arm_2d_copy.inc __arm_2d_draw_pattern.inc __arm_2d_fill_colour.inc arm_2d.c arm_2d_alpha_blending.c arm_2d_async.c arm_2d_conversion.c arm_2d_draw.c arm_2d_helium.c arm_2d_rotation.c
  group Arm-2D-Helper
    ../../Helper/Source/: arm_2d_helper_pfb.c
    ../../Helper/Include/: arm_2d_helper_pfb.h arm_2d_helper.h
  group Control
    ./controls/: busy_wheel.c busy_wheel.h controls.c controls.h shape_round_corner_box.c shape_round_corner_box.h spinning_wheel.c spinning_wheel.h
  group asset
    ./asset/: whilte_dot.c.c cmsis_logo.c helium.c small_icon_sun.c software.c SpinWheel.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Board Support:Drivers:SDRAM 1.1.1, CMSIS Driver:USART 1.16.0, Device:STM32Cube Framework:Classic 1.2.8, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:LTDC 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:STM32Cube HAL:SDRAM 1.2.8, Device:STM32Cube HAL:USART 1.2.8, Device:STM32Cube LL:Common 1.2.8, Device:STM32Cube LL:PWR 1.2.8, Device:STM32Cube LL:RCC 1.2.8, Device:STM32Cube LL:USART 1.2.8, Device:STM32Cube LL:UTILS 1.2.8, Device:Startup 1.2.5
