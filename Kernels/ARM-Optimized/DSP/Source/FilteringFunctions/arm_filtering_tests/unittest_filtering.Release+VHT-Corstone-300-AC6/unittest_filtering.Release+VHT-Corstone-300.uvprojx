# Keil uVision project unittest_filtering.Release+VHT-Corstone-300.uvprojx, settings and files
target Release+VHT-Corstone-300 (6200000::V6.20::.\ARMCLANG6.20)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.3.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00100000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: Release+VHT-Corstone-300.axf
  c flags: Optim=5 v6Lang=6 v6LangP=3
  c define: USE_ASM
  c misc: -ffast-math -ffast-math
  c include: ..
  asm define: USE_ASM
  asm include: ..
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x100000
  scatter file: ../RTE/Device/SSE-300-MPS3/fvp_sse300_mps3_s.sct
  link misc: --entry=Reset_Handler --info=summarysizes --info=sizes --info=totals --info=unused --info=veneers
  group App
    ../: arm_filtering_tests.c
    ../../: FilteringFunctions.c FilteringFunctionsF16.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.3, Device:Definition 1.2.0, Device:Startup 1.2.0, Native Driver:SysCounter 1.1.0, Native Driver:SysTimer 1.1.0, Native Driver:Timeout 1.0.0, Utilities:perf_counter:Core 1.9.11, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
