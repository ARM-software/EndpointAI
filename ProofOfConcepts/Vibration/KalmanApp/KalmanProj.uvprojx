# Keil uVision project KalmanProj.uvprojx, settings and files
target M4 (6140000::V6.14::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.1-dev0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: KalmanProj
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: data.c IO.cpp Kalman.cpp main.cpp
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.9.0-dev, Device:Startup 1.2.2, Compiler:I/O:STDOUT 1.2.0
